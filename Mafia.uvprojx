# Keil uVision project Mafia.uvprojx, settings and files
target Mafia (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mafia +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Lib\Drivers\include;.\Lib\Core\Device\NXP\LPC17xx\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup
    ./startup_LPC17xx/: startup_LPC17xx.s system_LPC17xx.c
  group Driver
    ./Lib/Drivers/source/: lpc17xx_exti.c lpc17xx_gpio.c lpc17xx_pinsel.c LPC1768_utility.c lpc17xx_clkpwr.c lpc17xx_libcfg_default.c lpc17xx_timer.c LPC1768_fnd.c
  group Core Code
    ./: core_cm3.c
  group Main
    ./: main.c GLCD.c
